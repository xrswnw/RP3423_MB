<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\Boot\RP3423_MB\Boot.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\RP3423_MB.ewp</path>
  </project>
  <batchBuild/>
</workspace>


