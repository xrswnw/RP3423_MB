# IAR project RP3423_MB.ewp, settings and files
configuration Build (ARM, debug)
  General.OGChipSelectEditMenu: GD32F303xC GD GD32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; _ANYID_GD32_; _ANYID_HSE12P00_; _ANYID_BOOT_GD32_; USE_FREE_RTOS; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\USB\inc; ..\StdLib\inc; ..\StdLib\startup; ..\OtrLib\inc; ..\kernel\inc; ..\kernel\portable; ..\kernel\portable\iar; ..\kernel\portable\MemMang; ..\kernel\periph\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\kernel\portable; ..\inc; E:\AnyID\Git\OSIO\kernel\portable
  OBJCOPY.OOCOutputFile: RP3423_MB.hex
  ILINK.IlinkOutputFile: RP3423_MB.out
  ILINK.IlinkIcfFile: GD32F303xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../StdLib/startup/: system_stm32f10x.c
  group EWARMv5
    ../StdLib/startup/: startup_stm32f10x_hd.s
  group Kernel
    ../kernel/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../kernel/portable/: FreeRTOSConfig.h
  group Kernel/Portable/iar
    ../kernel/portable/iar/: port.c portasm.s portmacro.h
  group Kernel/Portable/MemMang
    ../kernel/portable/MemMang/: heap_4.c
  group Main
    ../: main.c stm32f10x_conf.h stm32f10x_it.c
  group StdPeriph_Driver
    ../StdLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c vssver2.scc
  group User
    ../src/: AnyID_CanFestival_Can_HL.c AnyID_CanFestival_Device.c AnyID_CanFestival_Flash.c AnyID_CanFestival_Flash_HL.c AnyID_CanFestival_FlashM25.c AnyID_CanFestival_FRam.c AnyID_CanFestival_FRam_HL.c AnyID_CanFestival_Lan.c AnyID_CanFestival_Lan_HL.c AnyID_CanFestival_Periph_HL.c AnyID_CanFestival_SysCfg.c AnyID_CanFestival_Tim_HL.c AnyID_CanFestival_Uart.c AnyID_CanFestival_Uart_HL.c AnyID_CanFestival_Uart_Receive.c AnyID_CanFestival_WDG_HL.c AnyID_CanFestival_Wifi.c AnyID_CanFestival_Wifi_HL.c AnyID_FRam.c Rtos_HL.C
    ../OtrLib/src/: AnyID_Stdlib.c
